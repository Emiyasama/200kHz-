# Keil uVision project YT32B1_STM32F103_demo.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: YT32B1_STM32F103_demo +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\CMSIS;.\Lib\inc;.\Lib\src;.\User;.\Startup;.\Basic\delay;.\Basic\sys;.\Hardware\LED;.\Hardware\KEY;.\Hardware\TOUCH_KEY;.\Hardware\RELAY;.\Basic\usart;.\Hardware\OLED0561;.\Basic\i2c;.\Basic\tim;.\Basic\pwm;.\Basic\spi;.\Hardware\DAC;.\Hardware\AD9850;.\Basic\usart;.\Hardware\AD9850_2;.\DSP Library;.\Basic\adc;.\Hardware\TPad
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group Lib
    ./Lib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_flash.c stm32f10x_i2c.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_tim.c stm32f10x_spi.c
  group Startup
    ./Startup/: startup_stm32f10x_md.s
  group User
    ./User/: main.c stm32f10x_it.c
  group Basic
    ./Basic/delay/: delay.c
    ./Basic/sys/: sys.c
    ./Basic/i2c/: i2c.c
    ./Basic/pwm/: pwm.c
    ./Basic/spi/: spi.c
    ./Basic/usart/: usart.c
    ./Basic/adc/: bsp_adc.c
    ./Basic/tim/: tim.c
  group Hardware
    ./Hardware/LED/: led.c
    ./Hardware/KEY/: key.c
    ./Hardware/TOUCH_KEY/: touch_key.c
    ./Hardware/RELAY/: relay.c
    ./Hardware/OLED0561/: oled0561.c
    ./Hardware/DAC/: dac.c
    ./Hardware/AD9850/: AD9850.c
    ./Hardware/AD9850_2/: AD9850_2.c
    ./Hardware/TPad/: bsp_tpad.c
  group DSP Library
    ./DSP Library/: cr4_fft_256_stm32.s stm32_dsp.h table_fft.h
software components: CMSIS:CORE 5.3.0
