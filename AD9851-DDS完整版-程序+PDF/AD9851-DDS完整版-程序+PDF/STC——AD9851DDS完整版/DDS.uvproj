# Keil uVision project DDS.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: DDS +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\source
  group Source Group 1
    ./source/: DDS9851.C DHT11.C ds1302.c eeprom.c FunManage.c key.c main.c MCP41xx.c oled.c USART.C ADC.C
